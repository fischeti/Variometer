# Keil uVision project i2c_loopback.uvprojx, settings and files
target i2c_loopback (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ELITTLE
  output: i2c_loopback
  AfterMake: fromelf --bin --output bin\i2c_loopback.bin bin\i2c_loopback.axf
  AfterMake: fromelf -cedrst --output bin\i2c_loopback.txt bin\i2c_loopback.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_PART_APOLLO2 keil
  c include: ../src;../../../bsp;../../../../..;../../../../../utils;../../../../../devices;../../../../../mcu/apollo2;../../../../../mcu/apollo2/regs
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: .\i2c_loopback.sct
  link misc: ../../../../../mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: i2c_loopback.c
    ./: pwm_stuff.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_stdio.c am_util_faultisr.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo2/hal/keil/bin/: libam_hal.lib
